## nxp/sr100/Kconfig
```kconfig
#
# Nxp SPI SR100  devices
#

config NXP_SR100
	bool "Nxp SPI driver for SR100 devices"
```
